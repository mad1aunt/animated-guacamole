# IAR project Backup of PER test.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB; ..\include
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2530.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../source/: App_per_test_main.c basic_rf.c basic_rf_security.c clock.c hal_assert.c hal_board.c hal_int.c hal_mcu.c hal_rf.c hal_timer_32k.c iic.c LCD.c per_test_menu.c util.c util_buffer.c
